Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-02T08:27:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 02 08:27:09 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\b85d21fc-eb06-4e74-b20c-b7878fdba2c8\016fe1d6-fdce-4b63-a8b4-afaf5184b046\ifc * Database version: 5507 * Database creation date: Thu Feb 02 08:27:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 02 08:27:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 02 08:27:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12113000_J_KS4783ED_EDTCS:36478350_J_12113000_KS4783ED_EDTCS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 36478350_J_12113000_KS4783ED_EDTCS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 36478350_J_12113000_KS4783ED_EDTCS
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1850 mm; Depth: 675 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass, z_Miele_Design_BRWS
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355316
Description: Flow; FlowDirection: SOURCEANDSINK
